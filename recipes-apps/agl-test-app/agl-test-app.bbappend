require ${@bb.utils.contains('AGL_FEATURES', 'agl-flutter', 'agl-test-app_aglflutter.inc', '', d)}
